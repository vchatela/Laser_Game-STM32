# Keil uVision project Proj_Step_1.uvproj, settings and files
target Cible_STM103RB (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Proj_Step_1
  c flags: Optim=1
  c include: .\Lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Sources
    ./Sources/: principal.c Tempo.s Tempo son.s Affichage_Valise.h
    ../../: Trigo.asm
    ./: Signal.asm reel.asm t04f17p60.asm etat.h etat.inc bruitverre.asm
    ../: arghh.asm
  group Lib
    ./Lib/: gassp72.lib
    ./Sources/: Affichage_Valise.o
  group Sys
    ./Systeme/: startup-rvds.s
target Cible_Simulateur (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: Proj_Step_1
  c flags: Optim=1
  c include: .\Lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target Cible_reel (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: Proj_Step_1
  c flags: Optim=1
  c include: .\Lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
